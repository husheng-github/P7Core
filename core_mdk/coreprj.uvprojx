# Keil uVision project coreprj.uvprojx, settings and files
target CORE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: core +hex
  AfterMake: fromelf.exe --bin .\obj\core.axf --output=.\core.bin
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM4,TRENDIT_CORE
  c misc: --C99
  c include: ..\src;..\src\sdk;..\src\sdk\Libraries\CMSIS\Include;..\src\sdk\Libraries\MHSCPU_Driver\inc;..\src\sdk\Libraries\MHSCPU_Driver\inc\emvlib;..\src\sdk\Libraries\MHSCPU_Driver\inc\cryptlib;..\src\sdk\Libraries\Device\MegaHunt\mhscpu\Include;..\src\config;..\src\FreeRTOS\include;..\src\FreeRTOS\CMSIS_RTOS;..\src\FreeRTOS\portable\RVDS\ARM_CM3;..\src\ddi;..\src\pci;..\src\filesystem;..\src\filesystem\littlefs;..\src\sdk\Libraries\SCPU_USB_Lib\SCPU_USB_OTG_Driver\inc;..\src\sdk\Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Core\inc;..\src\sdk\Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Class\cdc\inc;..\src\devapi\dev_usb;..\src\devapi\dev_audio
  library: MicroLIB
  memory RVCT4: ROM 0x1018000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x9c000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../src/sdk/Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../src/sdk/Libraries/MHSCPU_Driver/src/: misc.c mhscpu_sysctrl.c mhscpu_gpio.c mhscpu_uart.c mhscpu_dma.c mhscpu_timer.c mhscpu_spi.c mhscpu_adc.c mhscpu_bpk.c mhscpu_crc.c mhscpu_exti.c mhscpu_rtc.c mhscpu_sensor.c mhscpu_trng.c mhscpu_ssc.c mhscpu_cache.c mhscpu_qspi.c mhscpu_dac.c mh_rand.c mhscpu_otp.c mhscpu_wdt.c
  group MHSCPU_lib
    ../src/sdk/Libraries/MHSCPU_Driver/lib/: crypt_lib.lib crypt_s_lib.lib MH1903S_EMV_Lib.lib MH1903S_MSR.lib QRDecodeLib.lib
  group CMSIS
    ../src/sdk/Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group FREERTOS
    ../src/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ../src/FreeRTOS/: queue.c tasks.c timers.c croutine.c event_groups.c list.c
    ../src/FreeRTOS/portable/MemMang/: heap_4.c
    ../src/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group boot
    ../src/boot/: bootmain.c
  group core
    ../src/core/: coremain.c
  group User
    ../src/user/: testmain.c test_interface.c
  group dev_gpio
    ../src/devapi/dev_gpio/: dev_gpio.c dev_gpioex.c
  group dev_irq
    ../src/devapi/dev_irq/: dev_irq.c
  group dev_uart
    ../src/devapi/dev_uart/: dev_uart.c drv_uart.c
  group dev_debug
    ../src/devapi/dev_debug/: dev_debug.c
  group dev_circlequeue
    ../src/devapi/dev_circlequeue/: dev_circlequeue.c
  group dev_maths
    ../src/devapi/dev_maths/: dev_maths.c
  group dev_memoryalloc
    ../src/devapi/dev_memoryalloc/: dev_memoryalloc.c
  group dev_misc
    ../src/devapi/dev_misc/: dev_system.c dev_misc.c drv_misc.c
  group dev_timer
    ../src/devapi/dev_timer/: dev_pwm.c dev_timer.c dev_usertimer.c drv_systick.c drv_timer.c
  group dev_spi
    ../src/devapi/dev_spi/: dev_spi.c drv_spi.c
  group dev_flash
    ../src/devapi/dev_flash/: drv_internalflash.c drv_qspiflash.c dev_flash.c drv_spiflash.c
  group dev_crypt
    ../src/devapi/dev_crypt/: dev_des.c dev_hash.c dev_rsa.c dev_sm.c dev_trng.c
  group dev_adc
    ../src/devapi/dev_adc/: dev_adc.c drv_adc.c
  group dev_dac
    ../src/devapi/dev_dac/: dev_dac.c drv_dac.c
  group dev_audio
    ../src/devapi/dev_audio/: dev_audio.c drv_audio.c ttsbin_handle.c
  group dev_keypad
    ../src/devapi/dev_keypad/: dev_keypad.c drv_keypad.c
  group filesystem
    ../src/filesystem/: fs.c
    ../src/filesystem/dynamicfile/: fs_dynamic.c
    ../src/filesystem/staticfile/: fs_static.c
    ../src/filesystem/sysfile/: fs_system.c fs_systembase.c
    ../src/filesystem/littlefs/: lfs.c lfs_util.c lfs_flash.c
  group dev_wifi
    ../src/devapi/dev_wifi/: dev_wifi.c dev_wifi_thread.c dev_wifi_wrapper.c drv_wifi_io.c wifi_control_strategy.c wifi_data_handle.c
  group dev_printer
    ../src/devapi/dev_printer/: dev_pt48d.c dev_pt48d_detect.c dev_pt48d_hw.c Barcode1D.c config-param.c DotFill.c esc_p.c Event.c font.c GT30L24M1Z.c Retarget.c
  group dev_pci
    ../src/pci/core/: pci_core_callfundefine.c pci_core_spstatus.c
    ../src/pci/keymanage/: pcipkmanage.c
    ../src/pci/pciarith/: pciarithdes.c pciarithhash.c pciarithrsa.c pciarithnormal.c pciarithscc.c pciarithsm2.c pciarithsm3.c
  group table
    ../src/table/: PitTable.c
  group ddi
    ../src/ddi/: ddi.c ddi_arith.c ddi_audio.c ddi_bt.c ddi_com.c ddi_dukpt.c ddi_elecsign.c ddi_file.c ddi_gprs.c ddi_iccpsam.c ddi_innerkey.c ddi_key.c ddi_lcd.c ddi_led.c ddi_mag.c ddi_mbedtls.c ddi_misc.c ddi_rf.c ddi_scanner.c ddi_sp.c ddi_thmprn.c ddi_watchdog.c ddi_wifi.c
  group dev_smc
    ../src/devapi/dev_smc/: dev_smc.c
  group dev_led
    ../src/devapi/dev_led/: dev_led.c
  group dev_power
    ../src/devapi/dev_power/: dev_power.c drv_power.c
  group dev_rtc
    ../src/devapi/dev_rtc/: dev_rtc.c
  group common
    ../src/devapi/common/: common.c
  group dev_qrcode
    ../src/devapi/dev_qrcode/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group dev_usb
    ../src/devapi/dev_usb/: dev_usbd_cdc.c hid_keyboard.c hid_keycode.c usb_bsp.c USBBSP.c usbd_cdc_vcp.c usbd_desc.c usbd_hid_bsp.c usbd_printer.c usbd_usr.c
  group dev_wireless
    ../src/devapi/dev_wireless/: dev_wireless.c dev_wireless_thread.c drv_wireless_io.c module.c module_FIBOCOM.c wireless_control_strategy.c wireless_data_handle.c
  group dev_dryice
    ../src/devapi/dev_dryice/: dev_dryice.c
  group dev_watchdog
    ../src/devapi/dev_wdog/: dev_watchdog.c drv_watchdog.c
  group scup_usb_otg_driver
    ../src/sdk/Libraries/SCPU_USB_Lib/SCPU_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group scup_usb_device_lib
    ../src/sdk/Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../src/sdk/Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
software components: CMSIS:CORE 5.3.0
