# Keil uVision project freertos.uvprojx, settings and files
target FLASH (ARM-ADS)
  device: ARMSC300 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("SC300") CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c misc: --C99
  c include: ..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User;..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\CMSIS_RTOS;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group User
    ../../User/: main.c mhunt_it.c
  group MDK-ARM
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_sysctrl.c mhscpu_gpio.c mhscpu_uart.c mhscpu_dma.c mhscpu_timer.c mhscpu_spi.c mhscpu_adc.c mhscpu_bpk.c mhscpu_crc.c mhscpu_exti.c mhscpu_rtc.c mhscpu_sensor.c mhscpu_trng.c mhscpu_ssc.c
  group CMSIS
    ../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group FREERTOS
    ../../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../FreeRTOS/Source/: queue.c tasks.c timers.c croutine.c event_groups.c list.c
    ../../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.3.0
